# Repository EcoTechTeam/Hardware

File README.md:

# Hardware
Repozytorium projektów hardware'owych EcoTech Team

Projekty tworzone w oprogramowaniu KiCad EDA. Obowiązuje następująca hierarchia folderów:

Hardware/Library - wspólna biblioteka symboli i obudów dla wszystkich projektów
Hardware/NazwaProjektu - Wszystkie pliki danego projektu PCB

Zasady wprowadzania zmian:
- Korzystamy z git flow: [https://danielkummer.github.io/git-flow-cheatsheet/]
- Gałąź Master zawiera wersje projektów, które poszły do produkcji
- Gałąź Develop zawiera aktualne projekty
- Gałęzie feature/Nazwa zawierają tymczasowe jeszcze nie skończone zmiany.

Workflow:
- Chcąc dodać zmiany branchujemy z developa.
- Wznawiając pracę na branchu synchronizujemy się z developem [merge albo rebase].
- Feature nie musi obejmować całego projektu od początku do końca, może zawierać drobne zmiany w bibliotece czy w którymś z projektów.
- Po zakończeniu pracy na feature mergujemy do developa squashując commity.
- Release do mastera jest równoznaczny z wypuszczeniem projektów do produkcji. Ostatnia wersja na masterze powinna zostać otagowana numerem zamówienia.

## KiCad design Telemetry/Telemetry.kicad_pcb

Board: 2 copper layers, 57.0 x 55.0 mm, 65 parts (0 on the bottom side), 37 nets.

Parts:
C4, C13, C15: 10u; C_0805_2012Metric
C5, C12, C14, C18, C19, C20, C21, C23: 100n; C_0603_1608Metric
C10, C11: 22p; C_0603_1608Metric
C16, C17: 1u; C_0805_2012Metric
C22: 100u; C_Radial_D5.0mm_H11.0mm_P2.00mm
D4, D5, D6, D7: GREEN; LED_0805_2012Metric
D8: D_TVS_ALT; D_SMC
D9: SM712.TCT; SOT-23
G1: EchoTech Team; EcoTech
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Micro_SD_Card; DM3AT-microSD
J5: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J7, J8: 4P4C
JP1: Jumper_NO_Small; PinHeader_1x02_P2.54mm_Vertical
JP3: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP4, JP5, JP6: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
L2: 10u; L_0805_2012Metric
Q3: Q_NMOS_GSD; SOT-23
R9, R10, R15, R18: 10k; R_0603_1608Metric
R11, R12, R13: 1k; R_0603_1608Metric
R14, R17: 100k; R_0603_1608Metric
R16: 120; R_0603_1608Metric
SW1, SW3: SW_Push; SW_SPST_TL3342
TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U3: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U4: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U5: LD1117S50TR_SOT223; SOT-223-3_TabPin2
U6: MCP1700-3302E_SOT23; SOT-23
Y1: 8Mhz; Crystal_SMD_HC49-SD

Connections:
+3.3VA: C21.1, L2.2, U4.9
+3V3: C12.1, C17.1, C18.1, C19.1, C20.1, C23.1, L2.1, R9.2, R15.1, TP14.1, U3.8, U4.1, U4.24, U4.36, U4.48, U6.2
+5V: C15.1, C16.1, J5.10, TP13.1, U5.2, U6.3
+12V: C4.1, C5.1, C13.1, C14.1, C22.1, D8.1, J7.2, J8.2, R10.1, TP10.1, U5.3
/2: J5.2, JP4.1, JP6.3
/4: J5.4, JP4.3
/6: J5.6, JP6.1
/A: D9.1, J7.3, J8.3, JP3.2, TP12.1, U3.6
/B: D9.2, J7.4, J8.4, R16.1, TP11.1, U3.7
/CS: J1.2, TP16.1, U4.14
/LED1: R11.2, U4.13
/LED2: R12.2, U4.12
/LED3: R13.2, U4.11
/MISO: J1.7, TP19.1, U4.16
/MOSI: J1.3, TP17.1, U4.17
/RST: JP1.2, R9.1, SW1.2, U4.7
/RX: U3.1, U4.22
/SCK: J1.5, TP18.1, U4.15
/SWCLK: JP6.2, U4.37
/SWDIO: JP4.2, U4.34
/TX: Q3.1, R18.1, U3.4, U4.21
GND: C4.2, C5.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D4.1, D5.1, D6.1, D7.1, D8.2, D9.3, J1.6, J7.1, J8.1, JP5.2, Q3.2, R14.2, R17.2, R18.2, SW1.1, SW3.2, TP15.1, U3.5, U4.8, U4.23, U4.35, U4.47, U5.1, U6.1
unnamed: C10.1, U4.5, Y1.1
unnamed: C11.1, U4.6, Y1.2
unnamed: C23.2, J1.4
unnamed: D4.2, R10.2
unnamed: D5.2, R11.1
unnamed: D6.2, R12.1
unnamed: D7.2, R13.1
unnamed: J5.1, JP1.1
unnamed: J5.3, JP5.1
unnamed: J5.5, JP5.3
unnamed: JP3.1, R16.2
unnamed: Q3.3, R15.2, U3.2, U3.3
unnamed: R14.1, U4.44
unnamed: R17.1, U4.20
unnamed: SW3.1, U4.38

## KiCad design SafetySystem/SafetySystem.kicad_pcb

Schematic: SafetySystem.sch

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 10u; C_1206_3216Metric
C2: 4u7; C_0805_2012Metric
C3: 22u; C_1210_3225Metric
C4, C5: 12p; C_0603_1608Metric
C6, C7, C8, C9: 100n; C_0603_1608Metric
D1: D_TVS_ALT; D_SMC
D2, D3, D4, D5, D6, D8: GREEN; LED_0805_2012Metric
D7: RED; LED_0805_2012Metric
D9, D10, D11, D12, D13, D14: D_ALT; D_MiniMELF
G1: EcoTechLogo; EcoTech_small
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3, J5, J6, J7, J8, J9, J10: Screw_Terminal_01x02; TerminalBlock_DG250_02P
J4: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
L1: 3u3; L_HPI0530-3R3
L2: 10u; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q1, Q2, Q3: Q_PMOS_GSD; SOT-23
Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: Q_NMOS_GSD; SOT-23
R1, R3, R8, R13, R16, R21, R22: 2k; R_0603_1608Metric
R2: 130k; R_0603_1608Metric
R4, R5, R7, R9, R10, R11, R12, R14, R15, R17, R20, R23, R24, R25, R26: 10k; R_0603_1608Metric
R6: 24k; R_0603_1608Metric
R18, R19: 1k; R_0603_1608Metric
RV1: 10k; Potentiometer_Runtron_RM-065_Vertical
SW2: SW_Push; SW_SPST_TL3342
SW3, SW4: SW_Push; SW_PUSH-12mm
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U1: ST1S10PHR; TI_SO-PowerPAD-8
U2: MQ-8; MQ8_hydrogen_sens
U3: ATmega8A-AU; TQFP-32_7x7mm_P0.8mm
U4, U5: LTV-817S; DIP-4_W7.62mm_LongPads
Y1: 8Mhz; Crystal_SMD_HC49-SD

Connections:
+5V: BZ1.1 (-), C3.1, C7.1, C9.1, J4.2 (VCC), L1.2, L2.1, R2.2, R3.1, R4.1, TP2.1, U2.4, U3.4 (VCC), U3.6 (VCC)
+5VA: C8.1, L2.2, RV1.3, U2.3, U3.18 (AVCC)
+12V: C1.1, C2.1, D9.1 (K), D10.1 (K), D13.1 (K), D14.1 (K), J2.1, J3.1, J5.1, J6.1, J9.1, J10.1, Q1.2 (S), Q2.2 (S), R1.1, R10.1, TP1.1, U1.1 (VINA), U1.2 (INH), U1.6 (VINSW), U4.4, U5.4
/ADC: R7.1, TP4.1, U2.1, U3.24 (PC1)
/ADC_POT: RV1.2, U3.23 (PC0)
/B1: J2.2, Q4.1 (G), R8.1, R9.1
/B2: J3.2, Q6.1 (G), R16.1, R17.1
/BUZZER: Q8.1 (G), R20.1, U3.14 (PB2)
/H2_SIG: Q7.1 (G), R15.1, U3.11 (PD7)
/INLET: D9.2 (A), J5.2, Q9.3 (D), SW4.1
/LED_G: R19.1, U3.13 (PB1)
/LED_R: R18.1, U3.12 (PB0)
/MISO: J4.9 (MISO), U3.16 (PB4)
/MOSI: J4.1 (MOSI), U3.15 (PB3)
/RST: J4.5 (~RST), R4.2, SW2.2, U3.29 (PC6/~RESET)
/SCK: J4.7 (SCK), U3.17 (PB5)
/SFT_SIG: Q3.3 (D), Q11.1 (G), Q12.1 (G), R12.1, R13.1, R25.1, R26.1, TP5.1
/S_R: Q5.1 (G), R12.2, R14.1, SW3.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.2 (A2), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J1.2, J4.4 (GND), J4.6 (GND), J4.8 (GND), J4.10 (GND), Q5.2 (S), Q7.2 (S), Q8.2 (S), Q11.2 (S), Q12.2 (S), R5.2, R6.1, R7.2, R9.2, R14.2, R15.2, R17.2, R20.2, R23.2, R24.2, R25.2, R26.2, RV1.1, SW2.1, TP3.1, U1.4 (AGND), U1.8 (PGND), U1.9 (PADGND), U2.2, U3.3 (GND), U3.5 (GND), U3.21 (AGND)
unnamed: BZ1.2 (+), Q8.3 (D)
unnamed: C4.1, U3.7 (PB6/XTAL1), Y1.1
unnamed: C5.1, U3.8 (PB7/XTAL2), Y1.2
unnamed: C6.1, U3.20 (AREF)
unnamed: D1.1 (A1), J1.1, Q1.3 (D)
unnamed: D2.2 (A), R1.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R13.2
unnamed: D6.2 (A), R16.2
unnamed: D7.2 (A), R18.2
unnamed: D8.2 (A), R19.2
unnamed: D10.2 (A), J6.2, Q10.3 (D)
unnamed: D11.1 (K), R21.1, U4.1
unnamed: D11.2 (A), J7.2, U4.2
unnamed: D12.1 (K), R22.1, U5.1
unnamed: D12.2 (A), J8.2, U5.2
unnamed: D13.2 (A), J9.2, Q9.2 (S), Q11.3 (D), SW4.2
unnamed: D14.2 (A), J10.2, Q10.2 (S), Q12.3 (D)
unnamed: J7.1, R21.2
unnamed: J8.1, R22.2
unnamed: L1.1, U1.7 (SW)
unnamed: Q1.1 (G), R5.1
unnamed: Q2.1 (G), Q4.3 (D), R10.2
unnamed: Q2.3 (D), Q3.2 (S), R11.1
unnamed: Q3.1 (G), Q5.3 (D), R11.2, SW3.1
unnamed: Q4.2 (S), Q6.3 (D)
unnamed: Q6.2 (S), Q7.3 (D)
unnamed: Q9.1 (G), R23.1, TP7.1, U4.3
unnamed: Q10.1 (G), R24.1, TP6.1, U5.3
unnamed: R2.1, R6.2, U1.3 (FB)

Notes on the sheet:
Wejścia na przyciski bezpieczeństwa
Wejście na zasilanie
Zabezpieczenie polaryzacji zasilania
Zabezpieczenie zasilania
Przetwornica DC/DC
Włącznik zasilania
Mikrokontroller- Atmega8
Złącze do programowania
Czujnik wodoru
Buzzer
Logika systemu bezpieczeństwa
Wejście sygnału zaworu dolotowego
Wyjścia sygnałów zaworu dolotowego
Przycisk zaworu dolotowego
Izolacja sygnału zaworu dolotowego
Wejście sygnału przekaźnika ogniwa
Wyjścia sygnałów przekaźnika ogniwa
Izolacja sygnału przekaźnika ogniwa
Diody LED
Przycisk resetu systemu bezpieczeństwa

Board: 2 copper layers, 70.0 x 60.0 mm, 96 parts (0 on the bottom side), 50 nets.

## KiCad design SystemSupply/SystemSupply.kicad_pcb

Schematic: SystemSupply.sch

Parts:
C1: 100n; C_0603_1608Metric
C2: 10n; C_0805_2012Metric
C3: 470u; C_Radial_D5.0mm_H11.0mm_P2.00mm; Voltage 50V
C4: 180u; C_Radial_D5.0mm_H11.0mm_P2.00mm; Voltage 50V
D1, D2, D5: D_TVS_ALT; D_SMC
D3: D_Schottky_ALT; D_MiniMELF
D6, D7: D_ALT; D_MiniMELF
F1: 20A; Fuse_Blade_90
G1: EcoTechLogo; EcoTech
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J4, J5: Conn_01x01; FlatConnector_63
J3, J7: 4P4C
J6, J8, J9, J10: Screw_Terminal_01x02; TerminalBlock_DG250_02P
JP1, JP2, JP3, JP4, JP5: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
K1: R30N
L1: 3u; L_1812_4532Metric_Pad1.30x3.40mm_HandSolder
L2: 3u; L_1812_4532Metric
Q1: Q_NMOS_GDS; TO-263-2
Q2: Q_NMOS_GSD; SOT-23
R1: 1Meg; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 100; R_0603_1608Metric
R3, R6: 10k; R_0603_1608Metric
R4: 120; R_0603_1608Metric
R5: 2k; R_0603_1608Metric
SW1, SW2: SW_SPDT; 5MS1S102AM2QE
SW3: SW_Push; SW_PUSH-12mm
TP1, TP5, TP6: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U1: LM5050; SOT-23-6
U2: DCDC_LM2596; LM2596_Board
U3: AXA01B18-L
U4: LTV-817S; DIP-4_W7.62mm_LongPads

Connections:
+12V: C4.1, D6.1 (K), J9.2, JP5.2, L2.1, SW1.1, SW2.1, TP5.1, U4.4
+24V: D3.2 (A), J1.1, JP2.1, Q1.2 (D), R2.1, U1.6 (D)
/IN+: C3.1, JP3.2, L1.2, U2.1 (IN+), U3.1 (Vin+)
/OUT+: JP5.1, L2.2, U2.3 (OUT+), U3.3 (Vout+)
GND: C4.2, D2.2 (A2), D5.2 (A2), J3.1, J7.1, J8.1, JP4.2, Q2.2 (S), R6.2, SW3.2, TP6.1, U2.4 (OUT-), U3.5 (Vout-)
GNDPWR: C1.2, C2.2, C3.2, D1.2 (A2), J4.1, J5.1, JP4.1, R1.2, R3.1, U1.2 (GND), U2.2 (IN-), U3.2 (Vin-)
unnamed: C1.1, R2.2, U1.1 (VS)
unnamed: C2.1, D3.1 (K), JP2.2, JP3.1, L1.1
unnamed: D1.1 (A1), K1.11, Q1.3 (S), R1.1, TP1.1, U1.4 (S)
unnamed: D2.1 (A1), J3.2, J7.2, SW1.2, SW1.3
unnamed: D5.1 (A1), J8.2, SW2.2, SW2.3
unnamed: D6.2 (A), J9.1, Q2.3 (D), SW3.1
unnamed: D7.1 (K), R5.1, U4.1
unnamed: D7.2 (A), J10.1, U4.2
unnamed: F1.1, K1.14
unnamed: F1.2, J2.1
unnamed: J3.3, J7.3, JP1.1
unnamed: J3.4, J7.4, R4.1
unnamed: J6.1, K1.A1
unnamed: J6.2, K1.A2
unnamed: J10.2, R5.2
unnamed: JP1.2, R4.2
unnamed: Q1.1 (G), U1.5 (G)
unnamed: Q2.1 (G), R6.1, U4.3
unnamed: R3.2, U1.3 (OFF)

Notes on the sheet:
Bezpiecznik
Przekaźnik ogniwa
Dioda ogniwa
Złącze wejściowe
Złącze wyjściowe
Złącze przekaźnika ogniwa
Włącznik zasilania magistrali
Złącze magistrali
Przycisk zaworu wylotowego
Złącze elektrozaworu wylotowego
Złącze sygnału elektrozaworu wylotowego
Opcjonalna terminacja magistrali
Dodatkowe złącze magistrali
Podły chińczyk
Zasilanie sterownika ogniwa
Filtr wejściowy
Filtr wyjściowy
Przemysłowy pewniak

Board: 2 copper layers, 75.0 x 75.0 mm, 52 parts (0 on the bottom side), 25 nets.

## KiCad design SafetySupply/SafetySupply.kicad_pcb

Parts:
C1: 470u; C_Radial_D10.0mm_H20.0mm_P5.00mm
C2, C3: 100n; C_0805_2012Metric
C4, C5, C6: 100n; C_0603_1608Metric
D1, D7, D8: RED; LED_0805_2012Metric
D2, D3: D_TVS_ALT; D_SMC
D4, D5: D_ALT; D_MiniMELF
D6: GREEN; LED_0805_2012Metric
F1: Fuse; Fuse_Blade_90
G1: EcoTechLogo; EcoTech_small
H1, H2: MountingHole; MountingHole_2.2mm_M2
J1, J3, J5: Screw_Terminal_01x02; TerminalBlock_DG250_02P
J2, J4, J6, J7, J8, J9: Conn_01x01; Pin_D1.4mm_L8.5mm_W2.8mm_FlatFork
K1: FRM18; RFM18
Q1, Q2, Q3: Q_PMOS_GSD; SOT-23
R1, R6, R10: 100; R_0603_1608Metric
R2, R4, R7, R9, R11, R13: 1k; R_0603_1608Metric
R3, R8, R12: 10k; R_0603_1608Metric
R5: 2k; R_0603_1608Metric
SW1: SW_SPDT; 5MS1S102AM6QE
U1, U3, U5: DW01-P; SOT-23-6
U2, U4, U6: FS8205A; TSSOP-8_4.4x3mm_P0.65mm

Connections:
+12V: C1.1, C2.1, D2.1 (A1), D5.1 (K), J5.1, K1.1, K1.3, R5.1, SW1.3 (C)
GND: C1.2, C2.2, C3.2, D2.2 (A2), D3.2 (A2), D4.2 (A), D6.1 (K), J1.2, J3.2, J5.2, R13.2, SW1.0, U6.6 (S2), U6.7 (S2)
unnamed: C3.1, D3.1 (A1), D4.1 (K), J1.1, K1.2
unnamed: C4.1, R1.1, U1.5 (VCC)
unnamed: C4.2, J4.1, R2.2, R3.2, U1.6 (GND), U2.2 (S1), U2.3 (S1)
unnamed: C5.1, R6.1, U3.5 (VCC)
unnamed: C5.2, J7.1, R7.2, R8.2, U3.6 (GND), U4.2 (S1), U4.3 (S1)
unnamed: C6.1, R10.1, U5.5 (VCC)
unnamed: C6.2, J9.1, R11.2, R12.2, U5.6 (GND), U6.2 (S1), U6.3 (S1)
unnamed: D1.1 (K), J2.1, Q1.3 (D)
unnamed: D1.2 (A), R2.1
unnamed: D5.2 (A), J3.1, K1.4
unnamed: D6.2 (A), R5.2
unnamed: D7.1 (K), J6.1, Q2.3 (D)
unnamed: D7.2 (A), R7.1
unnamed: D8.1 (K), J8.1, Q3.3 (D)
unnamed: D8.2 (A), R11.1
unnamed: F1.1, SW1.1 (A), SW1.2 (B)
unnamed: F1.2, Q1.2 (S), R1.2
unnamed: Q1.1 (G), R3.1
unnamed: Q2.1 (G), R8.1
unnamed: Q2.2 (S), R4.2, R6.2, U2.6 (S2), U2.7 (S2)
unnamed: Q3.1 (G), R12.1
unnamed: Q3.2 (S), R9.2, R10.2, U4.6 (S2), U4.7 (S2)
unnamed: R4.1, U1.2 (CS)
unnamed: R9.1, U3.2 (CS)
unnamed: R13.1, U5.2 (CS)
unnamed: U1.1 (OD), U2.4 (G1)
unnamed: U1.3 (OC), U2.5 (G2)
unnamed: U3.1 (OD), U4.4 (G1)
unnamed: U3.3 (OC), U4.5 (G2)
unnamed: U5.1 (OD), U6.4 (G1)
unnamed: U5.3 (OC), U6.5 (G2)

Notes on the sheet:
Złącze na klakson
Złącze na przycisk klaksonu
Włącznik zasilania
BMS
Dioda LED
Przekaźnik klaksonu
Bezpiecznik
Wyjście napięcia baterii
Zabezpieczenia napięcia baterii
Dodatkowe zabezpieczenia klaksonu

Board: 2 copper layers, 30.0 x 60.0 mm, 50 parts (0 on the bottom side), 33 nets.

## KiCad design MotorController/MotorController.kicad_pcb

Board: 2 copper layers, 55.0 x 45.0 mm, 44 parts (0 on the bottom side), 27 nets.

Parts:
C1, C3: 10u; C_0805_2012Metric
C2, C4, C5, C6, C9: 100n; C_0603_1608Metric
C7, C8: 22p; C_0603_1608Metric
D1: D_TVS_ALT; D_SMC
D2, D5, D6: NUP2105L; SOT-23
D3: RED; LED_0805_2012Metric
D4, D8: GREEN; LED_0805_2012Metric
G1: EcoTechLogo; EcoTech
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: 4P4C
J2: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
J3: 8P8C; MTJ-88GX1-FSD
J4: Screw_Terminal_01x02; TerminalBlock_DG250_02P
JP1: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
Q1: Q_NMOS_GSD; SOT-23
R1: 120; R_0603_1608Metric
R2, R3, R4: 10k; R_0603_1608Metric
R5, R6: 1k; R_0603_1608Metric
R7: 2k; R_0603_1608Metric
SW2: SW_Push; SW_SPST_TL3342
TP1, TP2, TP3, TP4, TP5: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U1: LD1117S50TR_SOT223; SOT-223-3_TabPin2
U2: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U3: ATmega8A-AU; TQFP-32_7x7mm_P0.8mm
Y1: 8Mhz; Crystal_SMD_HC49-SD

Connections:
+5V: C3.1, C4.1, C5.1, C6.1, J2.2, R2.1, R3.1, TP2.1, U1.2, U2.8, U3.4, U3.6, U3.18
+12V: C1.1, C2.1, D1.1, J1.2, R7.1, TP3.1, U1.3
/A: D2.1, J1.3, JP1.2, TP5.1, U2.6
/B: D2.2, J1.4, R1.2, TP4.1, U2.7
/B1: D5.1, J3.3, U3.1
/B2: D5.2, J3.4, U3.32
/B3: D6.1, J3.5, U3.24
/B4: D6.2, J3.6, U3.23
/BH_N: J3.7, J4.2
/BH_P: J3.8, J4.1
/LED_G: R6.1, U3.26
/LED_R: R5.1, U3.25
/MISO: J2.9, U3.16
/MOSI: J2.1, U3.15
/RST: J2.5, R2.2, SW2.2, U3.29
/RX: U2.1, U3.30
/SCK: J2.7, U3.17
/TX: Q1.1, R4.1, U2.4, U3.31
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.2, D2.3, D3.1, D4.1, D5.3, D6.3, D8.1, J1.1, J2.4, J2.6, J2.8, J2.10, J3.1, Q1.2, R4.2, SW2.1, TP1.1, U1.1, U2.5, U3.3, U3.5, U3.21
unnamed: C7.1, U3.7, Y1.1
unnamed: C8.1, U3.8, Y1.2
unnamed: C9.1, U3.20
unnamed: D3.2, R5.2
unnamed: D4.2, R6.2
unnamed: D8.2, R7.2
unnamed: JP1.1, R1.1
unnamed: Q1.3, R3.2, U2.2, U2.3

## Commit log

2019-02-09 Added new empty library.
2019-02-09 Added DW01-P symbol
2019-02-09 Added SOT-23-6 footprint.
2019-02-10 Added README.
2019-02-10 Squashed commit of the following:
    commit fe8d926a448a53d958445cac1a7e87946b76d859
    Author: Paweł <mackipawel@gmail.com>
    Date: Sun Feb 10 19:23:31 2019 +0100
    Completed SafetySupply schematic. Minor changes in library.
    commit e7eff7ec75384f70823e5243ef3bcfebd86644c9
    Author: Paweł <mackipawel@gmail.com>
2019-02-10 Fixed typo in README.
2019-02-11 Added horn protection diode. Added some footprints to the elements.
2019-02-12 Li-ion polarity protection
    commit b1813cd9200a201421d0e06ac9dd889f1f3910dd
    Author: Paweł <mackipawel@gmail.com>
    Date: Tue Feb 12 22:32:27 2019 +0100
    Added li-ion polarity protection.
2019-02-12 Minor designator change.
2019-02-21 Created schematic for SafetySystem including needed symbols in library.
    Squashed commit of the following:
    commit 8ffc4f6b6db923468d9555ee9fa313a703d10988
    Author: Paweł <mackipawel@gmail.com>
    Date: Thu Feb 21 22:32:22 2019 +0100
    Minor changes and some cleanup.
    commit fbeb508bde27228ae8acb8638352e5ba34f92933
2019-02-23 Removed varistors and added Atmega8 crystal resonator.
    Squashed commit of the following:
    commit fdff6d01c76f16de22ef88d4f0a11d1713a9c16b
    Author: Paweł <mackipawel@gmail.com>
    Date: Sat Feb 23 19:48:33 2019 +0100
    Removed varistors and added Atmega8 crystal resonator.
2019-02-23 Added SystemSupply schematic with Fuel Cell protections. Added LM5050 and LM74670-Q1 symbols.
2019-02-25 Added DC/DC converters symbols to Library. Added DC/DC converters, purging valve parts and bus connectors to the SystemSupply schematic.
2019-02-26 Added ground jumper.
2019-03-26 Footprint feature. Added some footprints to library.
    Squashed commit of the following:
    commit cd975fe41aefde478091de7f14ed38d0983c180d
    Author: Paweł <mackipawel@gmail.com>
    Date: Tue Mar 26 21:11:20 2019 +0100
    Added RFM18 and 5MS1S102AM2QE footprints.
    commit 4e602ef25fbcf5dd6c485f40bf8f72e3bcba2156
2019-03-29 Feature SafetySupply
    Squashed commit of the following:
    commit 9d5a0004d18ed8306ebf2eb05ad9a9ebf59c5dae
    Author: Paweł <mackipawel@gmail.com>
    Date: Fri Mar 29 23:23:41 2019 +0100
    Small fixes
    .
2019-03-30 Adding footprint of hydrogen sensor
2019-03-30 Feature SafetySystem footprints.
2019-03-30 Feature schematic annotation
    Squashed commit of the following:
    commit aec2ebb03e2dc3915f631c1ed1dd696ff1568698
    Author: Paweł <mackipawel@gmail.com>
    Date: Sat Mar 30 14:48:59 2019 +0100
    Annotated schematic.
2019-03-30 Feature SafetySystem footprints
    Squashed commit of the following:
    commit a1dfa4be279cdb3f1b8f20d08285cd25e64757a5
    Merge: 33d6e88 ce26f66
    Author: Paweł <mackipawel@gmail.com>
    Date: Sat Mar 30 15:05:37 2019 +0100
    Synchro with develop
2019-04-01 SystemSupply footprints
    Squashed commit of the following:
    commit 0bd7b2a681f9369231f8e24b93032b76762d25f9
    Author: Paweł <mackipawel@gmail.com>
    Date: Mon Apr 1 21:54:14 2019 +0200
    Added FlatConnector and R30N relay footprints. Added all footprints to symbols on SystemSupply.
    commit c64b223a18f0db3b17481c9f3533a511e4c60f06
2019-04-03 Motor Driver schematic
    Squashed commit of the following:
    commit 0293136829386dc40d79e2a79caf012ed3fafe34
    Author: Paweł <mackipawel@gmail.com>
    Date: Wed Apr 3 23:35:22 2019 +0200
    Checked schematic and resoved dc motor filtering problem.
    commit d8128957ed9383b90cc2b0df3a5da02ae8bd58ce
2019-04-09 Fixed silkscreen for SafetySupply, added mounting holes.
2019-04-10 System supply PCB
    Squashed commit of the following:
    commit dbc07ea87a8cb2914ffd081ab2f264bc75cd574d
    Author: Paweł <mackipawel@gmail.com>
    Date: Wed Apr 10 22:15:52 2019 +0200
    Added polygon pours and edited silk screen designators.
    commit e8e96d6977d739eab19b0dc30615939eafea5188
2019-04-10 MotorDriver conflicts.
2019-04-10 Added grounding vias in SystemSupply.
2019-04-10 Added grouding vias in SafetySupply.
2019-04-14 Motor controller Schematic and PCB
    Squashed commit of the following:
    commit 7e42ddace4110f895c6a227e3bac8c51cf20ee86
    Author: Paweł <mackipawel@gmail.com>
    Date: Sun Apr 14 11:59:55 2019 +0200
    Added RJ45 footprint. Added copper pours and placed designators on silkscreen.
    commit 5735f2a5db6ec7f9efeb39c8e2cf72f2fb58ce40
2019-04-15 First review. Fixed polygon pours, silkscreen and soldermask.
    Squashed commit of the following:
    commit 42a4a5d146683d2b2a8899b51cbc9eaef6797660
    Author: Paweł <mackipawel@gmail.com>
    Date: Tue Apr 16 00:20:58 2019 +0200
    Changed solder mask design rules. Changed polygon pours clearence.
    commit a27d25858da40b0edc55a62741cad58f571e73a1
2019-04-16 Small changes in copper pours.
2019-04-25 Finished SafetySystem PCB.
2019-04-25 Minor changes.
    Squashed commit of the following:
    commit b4817053897282ec246551fcbd580ae102a3b469
    Author: Paweł <mackipawel@gmail.com>
    Date: Thu Apr 25 22:57:44 2019 +0200
    Minor changes.
2019-04-28 SafetySystem potentiometer.
    Squashed commit of the following:
    commit c85b31eae362b98e5e9037a9aad6a815148d0818
    Author: Paweł <mackipawel@gmail.com>
    Date: Sun Apr 28 12:07:02 2019 +0200
    Added potentiometer to the SafetySysytem.
2019-04-28 Removed Switches from bus devices and added mounting holes in schematics.
    Squashed commit of the following:
    commit 448b4f84a5f64686dc4334a0b6d81609891ca7cf
    Author: Paweł <mackipawel@gmail.com>
    Date: Sun Apr 28 20:22:14 2019 +0200
    Added mouting holes to SystemSupply.
    commit d45917b7024ecbe087cb8328a2c33d3ab10399ff
2019-05-02 Added testpoints.
    Squashed commit of the following:
    commit b78741095f1293168643ce5f943c13a7eb09b318
    Author: Paweł <mackipawel@gmail.com>
    Date: Thu May 2 10:22:35 2019 +0200
    Added testpoints to remaining projects.
    commit d708f3fd02ddff10684a41533d76b9b66ea6c8f4
2019-05-06 Added 3D models to the library
    Squashed commit of the following:
    commit 8070c09fc3d8f70a7cb84d0f12b6782c2c87c14c
    Author: Paweł <mackipawel@gmail.com>
    Date: Mon May 6 20:26:56 2019 +0200
    Added SystemSupply 3d models.
    commit 94ef8708632c7bc91211bc6ded4e0c8fb9ccef4a
2019-05-09 Adding gerbers
2019-05-10 Moved gerbers, drill files and edge cuts to Output folders inside project. Removed empty bottom silk screen files.
2019-05-10 Removed SafetySupply bottom silk screen gerber.
2019-05-11 Changed all via diameters to 0.7. Added project and version label on silk screen. Added more grounding vias.
2019-05-11 Changed 1.1 to 1.0 versions.
2019-05-12 Added version date on silk screen and changed signal tracks width to 0,2.
2019-05-12 Gerber Fixes
2019-05-16 Removed MotorDriver bottom silk screen.
2019-12-25 .gitignore: Ignore no extention files
2019-12-25 MotorDriver/: Fix known issues
2019-12-25 CHANGELOG.md: Describe motor driver issues
2020-03-04 MotorDriver/: Fix pcb layout
2020-03-05 Telemetry/: Create telemetry project
2020-03-08 Telemetry.sch: Add SD Card connections to STM
2020-03-08 testowy.txt: Add test file
2020-03-13 Telemetry/: Update schema and create pcb layout
2020-03-15 Telemetry/: Create a pcd layout
2020-03-17 MotorDriver/: Add gerbers
2020-03-21 MotorDriver/: Unify names
2020-03-26 Telemetry/: add rev v1.0
2020-03-29 Create Telemetry PCB
2020-04-10 Telemetry.kicad_pcb: fix footprint F.SilkS layer
2020-04-10 Telemetry/: Gerber fixes
2020-05-23 Telemetry/: fix PCB size
2020-05-31 Telemetry/: add test points and rename PCB to v1.3
2020-08-31 Telemetry: bump version to 1.4
    - fix ground at PCB
    - change track width for 12V
    - change jumpers layout
    - change font size at fsilks layers
2020-08-31 Telemetry-v1.4.zip: add zipped gerber files
